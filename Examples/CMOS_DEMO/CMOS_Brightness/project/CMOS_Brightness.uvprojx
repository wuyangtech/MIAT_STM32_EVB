# Keil uVision project CMOS_Brightness.uvprojx, settings and files
target MIAT_STM32 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMOS_Brightness +hex
  c flags: Optim=1
  c include: ..\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\Obj\CMOS_Brightness.sct
  group Startup Code
    ../source/: stm32f10x_vector.s
  group Initialisation
    ../source/: STM32_Init.c
  group Source Code
    ../source/: stm32f10x_it.c CMOS_Brightness.c LCD_4bit.c BasicIO.c
  group Library
    ../library/: cmos.lib
software components: CMSIS:CORE 5.0.1
