# Keil uVision project ADC2TXTLCD.uvprojx, settings and files
target ADC2TEXTLCD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC2TEXTLCD +hex
  c flags: Optim=1
  c include: ..\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application files
    ../source/: main.c hw_config.c
  group LCDLib
    ../source/: lcd_func.c
  group FWLib
    ../library/: STM32F10xR.LIB
  group RVMDK
    ./: STM32F10x.s
software components: CMSIS:CORE 5.0.1
