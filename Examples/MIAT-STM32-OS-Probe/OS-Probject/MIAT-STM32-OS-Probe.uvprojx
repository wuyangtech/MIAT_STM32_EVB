# Keil uVision project MIAT-STM32-OS-Probe.uvprojx, settings and files
target Flash (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MIAT-STM32-OS-Probe +hex
  c flags: Optim=2 oTime=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .;..\BSP;..\uCOS-II\Ports\arm-cortex-m3\Generic\RealView;..\uCOS-II\Source;..\CPU\ST\STM32\inc;..\uC-CPU;..\uC-CPU\Arm-Cortex-M3\RealView;..\uC-LIB;..\uC-Probe\Target\Plugins\uCOS-II;..\uC-Probe\Target\Communication\Generic\Source;..\uC-Probe\Target\Communication\Generic\RS-232\Ports\ST\STM32;..\uC-Probe\Target\Communication\Generic\RS-232\Source;..\CPU-INC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\BSP\STM32_Flash.scat
  link misc: --entry ResetHndlr
  group APP
    ./: app.c app_cfg.h includes.h os_cfg.h vectors.s probe_com_cfg.h stm32f10x_conf.h
  group BSP
    ../BSP/: bsp.c bsp.h lcd.h fonts.h lcd.c init.s bsp_int.c bsp_periph.c hw_config.c lcd_func.c
  group FWL
    ../CPU-LIB/: STM32F10xR.LIB
  group uC-CPU
    ../uC-CPU/: cpu_def.h
    ../uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC-OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Port
    ../uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC-LIB
    ../uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC-Probe/Plugins/uCOS-II
    ../uC-Probe/Target/Plugins/uCOS-II/: os_probe.h os_probe.c
  group uC-Probe/Communication
    ../uC-Probe/Target/Communication/Generic/Source/: probe_com.c
    ../uC-Probe/Target/Communication/Generic/RS-232/Source/: probe_rs232.h
    ../uC-Probe/Target/Communication/Generic/OS/uCOS-II/: probe_com_os.c
  group uC-Probe/Communication/RS-232
    ../uC-Probe/Target/Communication/Generic/RS-232/Ports/ST/STM32/: probe_rs232c.c probe_rs232c.h
    ../uC-Probe/Target/Communication/Generic/RS-232/OS/uCOS-II/: probe_rs232_os.c
    ../uC-Probe/Target/Communication/Generic/RS-232/Source/: probe_rs232.c
    ../uC-Probe/Target/Communication/Generic/Source/: probe_com.h
  group Scatter
    ../BSP/: STM32_Flash.scat STM32_RAM.scat
software components: CMSIS:CORE 5.0.1
